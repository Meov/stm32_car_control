# Keil uVision project stm32_car_control.uvprojx, settings and files
target CAR_CONTROL (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\Libraries\inc;..\DeviceDrivers\CAN;..\DeviceDrivers\EXTI;..\DeviceDrivers\KEY;..\DeviceDrivers\LED;..\System\delay;..\System\shchdule;..\System\sys;..\System\usart;..\Application
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application
    ../Application/: main.c stm32f10x_it.c system_stm32f10x.c
  group Core
    ../CORE/: core_cm3.c startup_stm32f10x_ld.s
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_can.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_wwdg.c stm32f10x_tim.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_fsmc.c stm32f10x_dma.c stm32f10x_dbgmcu.c stm32f10x_dac.c stm32f10x_crc.c stm32f10x_cec.c stm32f10x_bkp.c stm32f10x_adc.c
  group System
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/shchdule/: timeslice.c list.c
  group DeviceDrivers
    ../DeviceDrivers/CAN/: can.c
    ../DeviceDrivers/EXTI/: exti.c
    ../DeviceDrivers/KEY/: key.c
    ../DeviceDrivers/LED/: led.c
